# Keil uVision project TQ2440.uvproj, settings and files
target TQ2440 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: RTT_TQ2440 +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o ./output/RTT_TQ2440.bin ./obj/RTT_TQ2440.axf
  c flags: Optim=1
  c include: ..\..\mini2440;..\..\..\include;..\..\..\libcpu\arm\s3c24x0;..\..\..\components\finsh;..\..\mini2440\LCD;..\..\..\components\rtgui\include;..\..\..\components\external\jpeg;..\..\..\components\rtgui\include\rtgui\widgets;..\..\..\components\external\libpng;..\..\..\components\external\libz;..\..\..\components\external\ftk
  memory RVCT1: ROM 0x30000000 size 0x100000
  memory RVCT6: RAM 0x30100000 size 0x400000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\rtthread-mini2440.sct
  group startup
    ../: application.c board.c console.c key.c led.c sdcard.c startup.c touch.c lcd_w35.c
  group kernel
    ../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c slab.c thread.c timer.c
  group port
    ../../../libcpu/arm/s3c24x0/: context_rvds.S cpu.c interrupt.c mmu.c rtc.c serial.c stack.c start_rvds.S system_clock.c trap.c
  group finsh
    ../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group wediget
    ../../../components/rtgui/widgets/: about_view.c box.c button.c checkbox.c combobox.c container.c filelist_view.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c notebook.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c textbox.c textview.c title.c toplevel.c view.c widget.c window.c workbench.c
  group comm
    ../../../components/rtgui/common/: color.c font_bmp.c font_freetype.c font_hz_bmp.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c pixel_driver.c region.c rtgui_object.c rtgui_system.c asc12font.c asc16font.c blit.c dc.c dc_buffer.c dc_client.c dc_hw.c filerw.c font.c image_container.c image_hdc.c image_xpm.c rtgui_theme.c rtgui_xml.c image.c image_bmp.c image_jpg.c image_png.c
  group server
    ../../../components/rtgui/server/: driver.c mouse.c panel.c server.c topwin.c
  group demo
    ../../../examples/gui/: demo_fnview.c demo_listview.c demo_listview_icon.c demo_panel.c demo_simple_workbench.c demo_view.c demo_view_animation.c demo_view_benchmark.c demo_view_box.c demo_view_buffer_animation.c demo_view_button.c demo_view_checkbox.c demo_view_combobox.c demo_view_dc.c demo_view_dc_buffer.c demo_view_image.c demo_view_instrument_panel.c demo_view_label.c demo_view_listbox.c demo_view_listctrl.c demo_view_menu.c demo_view_module.c demo_view_mywidget.c demo_view_notebook.c demo_view_progressbar.c demo_view_radiobox.c demo_view_scrollbar.c demo_view_slider.c demo_view_textbox.c demo_view_ttf.c demo_view_window.c demo_workbench.c demo_xml.c gui_init.c mywidget.c
