# Keil uVision project debug.uvproj, settings and files
target RT-Thread Debug (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: rtthread-mini2440
  c flags: Optim=1
  memory RVCT9: RAM 0x40000000 size 0x1000
